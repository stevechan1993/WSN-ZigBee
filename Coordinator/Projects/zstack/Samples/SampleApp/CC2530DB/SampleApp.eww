<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SampleApp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\..\EndDevice_DHT11\Projects\zstack\Samples\SampleApp\CC2530DB\SampleApp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\..\EndDevice_Light\Projects\zstack\Samples\SampleApp\CC2530DB\SampleApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SampleApp</project>
        <configuration>DemoEB</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>EndDeviceEB-DHT11</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>EndDeviceEB-LIGHT</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


